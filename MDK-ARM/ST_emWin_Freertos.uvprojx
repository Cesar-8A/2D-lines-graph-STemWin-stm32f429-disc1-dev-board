# Keil uVision project ST_emWin_Freertos.uvprojx, settings and files
target ST_emWin_Freertos (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: ST_emWin_Freertos +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../STemWin/Target;../STemWin/App;../USB_HOST/App;../USB_HOST/Target;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/STM32F4xx_HAL_Driver/Inc;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/include;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/BSP/Components/ili9341;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STM32_USB_Host_Library/Core/Inc;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Inc;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/CMSIS/Device/ST/STM32F4xx/Include;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STemWin/inc;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/BSP/Components/Common;C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/CMSIS/Include;C:\Users\Alber\STM32Cube\Repository\STM32Cube_FW_F4_V1.24.1\Drivers\BSP\STM32F429I-Discovery;C:\Users\Alber\STM32Cube\Repository\STM32Cube_FW_F4_V1.24.1\Drivers\BSP\Components\stmpe811;..\MDK-ARM
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/BSP/STM32F429i-Discovery
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c crc.c dac.c freertos.c i2c.c spi.c sys.c stm32f4xx_hal_timebase_tim.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ./: GraphQueue_manager.c GraphQueue_manager.h cat_1_bmp.c cat_2_bmp.c cat_3_bmp.c cat_4_bmp.c cat_bmp.h
  group Application/User/STemWin/App
    ../STemWin/App/: velocimetroDLG.c GUI_App.c
  group Application/User/STemWin/Target
    ../STemWin/Target/: GUIConf.c HW_Init.c STemwin_wrapper.c
  group Application/User/USB_HOST/App
    ../USB_HOST/App/: usb_host.c
  group Application/User/USB_HOST/Target
    ../USB_HOST/Target/: usbh_conf.c usbh_platform.c
  group Drivers/BSP/Components
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/BSP/Components/stmpe811/: stmpe811.c
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/BSP/Components/ili9341/: ili9341.c
  group Drivers/STM32F4xx_HAL_Driver
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_hcd.c stm32f4xx_ll_usb.c stm32f4xx_hal_crc.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/STemWin
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STemWin/Lib/: STemWin_CM4_OS_wc16_ot_ARGB.a
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STemWin/OS/: GUI_X_OS.c
  group Middlewares/USB_Host_Library
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
    C:/Users/Alber/STM32Cube/Repository/STM32Cube_FW_F4_V1.24.1/Middlewares/ST/STM32_USB_Host_Library/Class/CDC/Src/: usbh_cdc.c
software components: CMSIS:CORE 4.3.0
